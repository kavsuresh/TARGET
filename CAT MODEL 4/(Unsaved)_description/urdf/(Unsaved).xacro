Commit message: Update (Unsaved).xacro

File: CAT MODEL 4/(Unsaved)_description/urdf/(Unsaved).xacro (robot description, xacro)
@@ -74,5 +74,5 @@
   <parent link="base_link"/>
   <child link="right_wheel_1"/>
-  <axis xyz="-0.0 -0.0 1.0"/>
+  <axis xyz="0.0 0.0 1.0"/>
 </joint>
 </robot>
